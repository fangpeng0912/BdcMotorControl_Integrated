# Keil uVision project bdcMotorControl.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: systick_interupt +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\User\StdPeriph Driver\inc;.\User\Me
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./User/: main.c startup_stm32f10x_md.s core_cm3.c system_stm32f10x.c
  group StdPeriph Driver
    ./User/StdPeriph Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_tim.c
  group Me
    ./User/Me/: systick_interupt_light_LED.c RS232.c HAL_BdcMotorControl.c HAL_Encoder.c APP_SpeedControl.c APP_Desired_RPM.c
